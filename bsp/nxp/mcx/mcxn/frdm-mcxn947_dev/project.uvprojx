# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6190000::V6.19::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, CPU_MCXN947VDF_cm33_core0, CONFIG_USB_HS, RT_USING_LIBC, __RTTHREAD__, DEBUG, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\net\lwip\port;..\..\..\..\..\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\..\..\components\dfs\dfs_v1\filesystems\tmpfs;board;packages\rw007-latest\inc;..\Libraries\CMSIS\Core\Include;packages\webnet-latest\inc;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\Libraries\drivers\config;..\..\..\..\..\components\drivers\usb\cherryusb\core;..\..\..\..\..\components\drivers\smp;..\Libraries\MCXN947\MCXN947\drivers\romapi\flash;..\..\..\..\..\components\net\sal\include\dfs_net;..\..\..\..\..\components\drivers\spi\sfud\inc;..\..\..\..\..\libcpu\arm\cortex-m33;.;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\..\..\components\drivers\usb\cherryusb\class\wireless;..\..\..\..\..\components\drivers\include;..\Libraries\drivers;..\Libraries\MCXN947\MCXN947\drivers;..\..\..\..\..\components\libc\posix\io\stdio;..\..\..\..\..\components\libc\posix\io\termios;..\..\..\..\..\components\finsh;..\Libraries\MCXN947\MCXN947\drivers\romapi\runbootloader;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\drivers\wlan;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\..\..\components\net\sal\include\socket;..\..\..\..\..\components\utilities\ymodem;applications;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\..\..\components\libc\compilers\common\include;..\Libraries\MCXN947\MCXN947\drivers\romapi\nboot;..\..\..\..\..\components\net\sal\impl;..\..\..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\usb\cherryusb\class\cdc;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\components\drivers\usb\cherryusb\common;..\..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\..\components\net\sal\include;..\..\..\..\..\components\drivers\include;..\Libraries\MCXN947\MCXN947;..\..\..\..\..\components\drivers\usb\cherryusb\osal;..\..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\..\components\libc\compilers\common\extension;..\Libraries\MCXN947\MCXN947\drivers\romapi\mem_interface;board\MCUX_Config\board;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\dfu;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;packages\rw007-latest;..\..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\serial;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\hid
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: main.c
  group CherryUSB
    ../../../../../components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usb_msh.c
    ../../../../../components/drivers/usb/cherryusb/class/msc/: usbd_msc.c
    ../../../../../components/drivers/usb/cherryusb/core/: usbd_core.c
    ../../../../../components/drivers/usb/cherryusb/port/chipidea/: usb_dc_chipidea.c usb_glue_mcx.c
    ../../../../../components/drivers/usb/cherryusb/class/hid/: usbd_hid.c
    ../../../../../components/drivers/usb/cherryusb/class/cdc/: usbd_cdc_acm.c
    ../../../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/sdio/: dev_block.c dev_gpt.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../../components/drivers/wlan/: dev_wlan.c dev_wlan_cfg.c dev_wlan_cmd.c dev_wlan_lwip.c dev_wlan_mgnt.c dev_wlan_prot.c dev_wlan_workqueue.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_app.c usb_phy.c
    board/ports/: app_init_filesystem.c drv_spi_sample_rw007.c
    ../Libraries/drivers/: drv_pin.c drv_sdio.c drv_spi.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../components/dfs/dfs_v1/filesystems/tmpfs/: dfs_tmpfs.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: msh_file.c cmd.c msh_parse.c msh.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_powerquad_basic.c fsl_pdm_edma.c fsl_flexio_uart.c fsl_tsi_v6.c fsl_sai_edma.c fsl_sai.c fsl_vref.c fsl_tdet.c fsl_flexio_mculcd_edma.c fsl_enet.c fsl_flexcan_edma.c fsl_flexio.c fsl_intm.c fsl_cache_lpcac.c fsl_vbat.c fsl_dac14.c fsl_lpadc.c fsl_powerquad_data.c fsl_powerquad_math.c fsl_flexcan.c fsl_sema42.c fsl_lpuart.c fsl_flexio_spi_edma.c fsl_lpcmp.c fsl_i3c.c fsl_pdm.c fsl_puf_v3.c fsl_reset.c fsl_flexspi.c fsl_crc.c fsl_irtc.c fsl_itrc.c fsl_smartcard_phy_emvsim.c fsl_ctimer.c fsl_eim.c fsl_gdet.c fsl_smartdma.c fsl_flexio_uart_edma.c fsl_sctimer.c fsl_spc.c fsl_edma_soc.c fsl_i3c_edma.c fsl_cmc.c fsl_syspm.c fsl_flexio_mculcd_smartdma.c fsl_inputmux.c fsl_ostimer.c fsl_lpuart_edma.c fsl_lptmr.c fsl_utick.c fsl_ewm.c fsl_clock.c fsl_mrt.c fsl_powerquad_filter.c fsl_usdhc.c fsl_erm.c fsl_wuu.c fsl_common_arm.c fsl_opamp.c fsl_powerquad_matrix.c fsl_gpio.c fsl_lpi2c.c fsl_pwm.c fsl_evtg.c fsl_freqme.c fsl_cdog.c fsl_pint.c fsl_qdc.c fsl_flexio_spi.c fsl_plu.c fsl_smartdma_mcxn.c fsl_lpi2c_edma.c fsl_power.c fsl_cache.c fsl_smartcard_emvsim.c fsl_powerquad_transform.c fsl_lpspi.c fsl_flexio_mculcd.c fsl_lpspi_edma.c fsl_sinc.c fsl_flexio_i2c_master.c fsl_wwdt.c fsl_flexspi_edma.c fsl_trdc.c fsl_smartdma_rt500.c fsl_edma.c fsl_dac.c fsl_lpflexcomm.c fsl_common.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    ../Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
  group lwIP
    ../../../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    ../../../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../../../components/libc/posix/io/stdio/: stdio.c
    ../../../../../components/libc/posix/io/termios/: termios.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rw007
    packages/rw007-latest/src/: spi_wifi_rw007.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ymodem/: ry_sy.c ymodem.c
  group WebNet
    packages/webnet-latest/src/: webnet.c wn_request.c wn_mimetype.c wn_session.c wn_utils.c wn_module.c
    packages/webnet-latest/samples/: wn_sample_upload.c wn_sample.c
    packages/webnet-latest/module/: wn_module_log.c wn_module_alias.c wn_module_upload.c wn_module_cgi.c wn_module_asp.c wn_module_ssi.c wn_module_index.c wn_module_auth.c
