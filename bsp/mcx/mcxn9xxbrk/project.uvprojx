# Keil uVision project project.uvprojx, settings and files
target rtthread-mcxn9xxbrk (6190000::V6.19::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\Libraries\drivers;.;..\Libraries\MCXN947\middleware\sdmmc\inc;..\Libraries\MCXN947\MCXN947\drivers;board\MCUX_Config\board;..\Libraries\MCXN947\MCXN947;board;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\cortex-m33;..\..\..\include;..\..\..\components\libc\posix\io\stdio;..\Libraries\CMSIS\Core\Include;..\Libraries\MCXN947\components\codec;..\..\..\components\libc\compilers\common\extension;applications;..\Libraries\drivers\config;..\Libraries\MCXN947\middleware\sdmmc\port;..\..\..\components\drivers\include;..\..\..\components\drivers\include
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_clock.c fsl_flexcan.c fsl_edma.c fsl_flexio_mculcd.c fsl_crc.c fsl_lpspi.c fsl_mrt.c fsl_lpuart.c fsl_cmc.c fsl_flexio_spi_edma.c fsl_flexio_mculcd_edma.c fsl_dac.c fsl_lptmr.c fsl_common_arm.c fsl_reset.c fsl_vref.c fsl_flexio_uart_edma.c fsl_lpi2c_edma.c fsl_irtc.c fsl_erm.c fsl_dac14.c fsl_gpio.c fsl_lpi2c.c fsl_flexspi.c fsl_flexspi_edma.c fsl_ewm.c fsl_flexio_i2c_master.c fsl_ctimer.c fsl_flexio_uart.c fsl_enc.c fsl_i3c.c fsl_cache_lpcac.c fsl_enet.c fsl_lpflexcomm.c fsl_flexio.c fsl_edma_soc.c fsl_evtg.c fsl_itrc.c fsl_cache.c fsl_eim.c fsl_cdog.c fsl_flexio_spi.c fsl_common.c
    ../Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
